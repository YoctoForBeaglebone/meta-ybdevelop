DEPENDS += "v4l-utils"
PACKAGECONFIG += "v4l"
PACKAGECONFIG += "h264"
