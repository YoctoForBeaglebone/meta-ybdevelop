IMAGE_INSTALL_append = " packagegroup-yb-develop"